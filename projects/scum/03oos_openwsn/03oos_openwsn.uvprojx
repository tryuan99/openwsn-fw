# Keil uVision project 03oos_openwsn.uvprojx, settings and files
target Target SCuM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.3.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: 03oos_openwsn
  AfterMake: fromelf --bin .\Objects\03oos_openwsn.axf -o .\Objects\03oos_openwsn.bin
  AfterMake: fromelf -cvf .\Objects\03oos_openwsn.axf -o .\Objects\disasm.txt
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: SCUM, SCUM_DEBUG OPENWSN_UDP_C OPENWSN_USENSOR_NETWORK_C
  c misc: --gnu
  c include: ..\..\..\bsp\boards\scum;..\..\..\bsp\boards;..\..\..\drivers\common;..\..\..\inc;..\..\..\openstack\02a-MAClow;..\..\..\openstack\02b-MAChigh;..\..\..\openstack\03a-IPHC;..\..\..\openstack\03b-IPv6;..\..\..\openstack\04-TRAN;..\..\..\openstack\cross-layers;..\..\..\kernel;..\..\..\openstack;..\..\..\bsp\boards\common;..\..\..\drivers\common\crypto;..\..\..\openweb;..\..\..\openapps;..\..\..\openstack\04-TRAN\sock;..\..\..\openapps/usensor_network
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group application
    ../../common/03oos_openwsn/: 03oos_openwsn.c
  group boards
    ../../../bsp/boards/: board.h debugpins.h eui64.h leds.h uart.h sctimer.h
  group scum
    ../../../bsp/boards/scum/: cm0dsasm.s leds.c memory_map.h board_info.h board.c uart.c debugpins.c radio.c eui64.c sctimer.c cryptoengine.c retarget.c radio.h adc.c optical.c scm3c_hw_interface.c channel_cal.c channel_cal.h channel.c channel.h tuning_feedback.c tuning_feedback.h tuning.c tuning.h gpio.c gpio.h
  group drivers
    ../../../drivers/common/: opentimers.c openhdlc.c openserial.c
    ../../../drivers/common/crypto/: aes128.c ccms.c hkdf.c hmac.c sha224-256.c usha.c
  group inc
    ../../../inc/: opendefs.h
  group stack_initial
    ../../../openstack/: openstack.c openstack.h
  group 02a-MAClow
    ../../../openstack/02a-MAClow/: IEEE802154.c IEEE802154_security.c IEEE802154E.c topology.c
  group 02b-MAChigh
    ../../../openstack/02b-MAChigh/: neighbors.c schedule.c msf.c sixtop.c
  group cross-layers
    ../../../openstack/cross-layers/: idmanager.c openqueue.c openrandom.c packetfunctions.c
  group kernel
    ../../../kernel/openos/: scheduler.c
  group 03a-IPHC
    ../../../openstack/03a-IPHC/: iphc.c openbridge.c frag.c
  group 03b-IPv6
    ../../../openstack/03b-IPv6/: forwarding.c icmpv6.c icmpv6echo.c icmpv6rpl.c
  group 04-TRAN
    ../../../openstack/04-TRAN/: udp.c
    ../../../openstack/04-TRAN/sock/: async_types.h async.h sock_internal.h sock_types.h sock.c sock.h
  group openwsb
    ../../../openweb/: openweb.c
  group openapp
    ../../../openapps/: openapps.c
    ../../../openapps/usensor_network/: sensor_potentiometric.c sensor_potentiometric.h sensor.h sensors.c sensors.h usensor_network.c usensor_network.h
